include recipes-core/images/core-image-minimal.bb

IMAGE_INSTALL += "openssh vsomeip"


